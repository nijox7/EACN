<?xml version="1.0"?>
<setupdb version="6">test
	<active>Active Setup</active>
	<history>History</history>
</setupdb>
